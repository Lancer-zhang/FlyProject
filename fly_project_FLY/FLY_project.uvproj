# Keil uVision project FLY_project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: FLY_project +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\CMSIS;.\CODE;.\STM32_LIB\inc;.\STM32_LIB\src;.\USER;.\CMSIS\STARTUP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group CODE
    ./CODE/: delay.c HMC5883L.c I2C.c IMU.c mpu6050.c pwm.c USART.c Pid.c led.c SPI_NRF.c Timer.c
  group STM32_LIB
    ./STM32_LIB/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_spi.c
  group USER
    ./USER/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group STARTUP
    ./CMSIS/STARTUP/: startup_stm32f10x_md.s
